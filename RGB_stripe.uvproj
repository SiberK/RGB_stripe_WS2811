# Keil uVision project RGB_stripe.uvproj, settings and files
target Target F100C4 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: firmware +hex
  c flags: Optim=1
  c define: STM32F10X_MD_VL, USE_STDPERIPH_DRIVER
  c include: .\USER;.\SysTick;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./user/: startup_stm32f10x_ld_vl.s
    ./SysTick/: stm32f10x_systick.c systick.c
    ./USER/: SystemInit.c startup_stm32f10x_hd.s
  group Lib
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_tim.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c stm32f10x_spi.c stm32f10x_dma.c
  group User
    ./USER/: Main.cpp RGB_strip.cpp Effect.cpp
target Target F103VE (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: firmware +hex
  c flags: Optim=1
  c define: STM32F10X_HD  USE_STDPERIPH_DRIVER BOARD_PORT103V
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
